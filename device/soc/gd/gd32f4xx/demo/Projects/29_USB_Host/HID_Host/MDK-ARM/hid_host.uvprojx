# Keil uVision project hid_host.uvprojx, settings and files
target USBFS_usbh_hid (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F470IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USBH-HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F470
  c include: ..\inc;..\..\..\..\Utilities;..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\driver\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\host\class\hid\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\host\core\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\class\hid;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: main.c usbh_usr.c gd32f4xx_it.c usbh_usr_lcd.c gd32f4xx_usb_hw.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c
  group GD32F4xx_EVAL
    ../src/: lcd_font.c lcd_log.c gd32f470i_lcd_eval.c gd32f470i_eval_exmc_sdram.c gd32f470i_eval.c
  group USB_Drivers
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group Startup
    ../../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ../: readme.txt
target USBHS_usbh_hid (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F470IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: as above
  output: USBH-HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470,USE_USB_HS,USE_ULPI_PHY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.3.0
