# Keil uVision project Project.uvproj, settings and files
target GD32470I_EVAL (ARM-ADS)
  device: GD32F450IK GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GD32450I_EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS;..\..\..\Third_party\lwip-2.2.1\src\include;..\..\..\Third_party\lwip-2.2.1\src\include\ipv4;..\..\..\Third_party\lwip-2.2.1\src\include\netif;..\..\..\Third_party\lwip-2.2.1\src\include\lwip;..\..\..\Third_party\lwip-2.2.1\port\GD32F4xx;..\..\..\Third_party\lwip-2.2.1\port\GD32F4xx\FreeRTOS;..\..\..\Third_party\lwip-2.2.1\port\GD32F4xx\arch;..\..\..\Third_party\FreeRTOS-Kernel-11.2.0\include;..\..\..\Third_party\FreeRTOS-Kernel-11.2.0\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: main.c gd32f4xx_it.c gd32f4xx_enet_eval.c netconf.c hello_gigadevice.c tcp_client.c udp_echo.c
  group GD32F4xx_Peripherals
    ../../../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Lwip
    ../../../Third_party/lwip-2.2.1/src/core/: def.c dns.c init.c altcp.c altcp_alloc.c altcp_tcp.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.2.1/src/core/ipv4/: dhcp.c autoip.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c acd.c
    ../../../Third_party/lwip-2.2.1/src/netif/: ethernet.c
    ../../../Third_party/lwip-2.2.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip_port
    ../../../Third_party/lwip-2.2.1/port/GD32F4xx/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../../../Third_party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../Third_party/FreeRTOS-Kernel-11.2.0/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f470i_eval.c
  group Startup
    ../../../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ../: readme.txt
